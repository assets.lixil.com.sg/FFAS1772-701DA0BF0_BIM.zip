Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-24T05:31:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 24 05:31:53 2025 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\5eadb9b7-44ea-4f8f-8c2f-4452451b09bc\1a2af126-7c0b-438c-91ad-4200e474abc7\ifc * Database version: 5507 * Database creation date: Fri Oct 24 05:31:46 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 24 05:31:47 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 24 05:31:47 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAS1772-701XX0BF0_REVT:FFAS1772-701A00BT0, FFAS1772-701XX0BF0_REVT:FFAS1772-701A00BT0:348410
In: Level 1
Type - Material: American Standard - Brass - Polished Hard Graphite
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: FFAS1772-701A00BT0
Material: American Standard - Brass - Polished Hard Graphite, American Standard - Plastic
Pset_DistributionFlowElementCommon - Reference: FFAS1772-701A00BT0; sets with these values: 2
